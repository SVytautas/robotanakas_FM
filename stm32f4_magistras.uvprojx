# Keil uVision project stm32f4_magistras.uvprojx, settings and files
target Roboto_prog_failai (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_magistras
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE=8000000 ARM_MATH_CM4
  c include: ..\STM32f4_magistras;.\i2c;.\extra_lib;..\Robotankas_FM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group prog_failai
    ./: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c plokstes_init.c zingsniniai_varikliai.c Lidar.c debuguart.c OFS.c Servo.c Griebtuvas.c Trasos_iveikimas.c ADC.c COLOR.c Maiselio_ieskojimas.c PD8544.c btn_nokia.c Ekranas_atv.c Ultragarsas.c btn_bumper.c papildomi.c gps_compass.c delay_simple.c dstar.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:USART 1.4.2, Device:Startup 2.4.2
